# Keil uVision project Bootloader_v1.uvprojx, settings and files
target Bootloader_v1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Bootloader_v1 +hex
  AfterMake: D:\program\MDK_ARM\KeilC\ARM\ARMCC\bin\fromelf.exe --bin Bootloader_v1\Bootloader_v1.axf --output Bootloader_v1\Bootloader_v1.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F769xx
  c include: ../Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;..\Drivers\User_Library\sys;..\Drivers\User_Library\op;..\Drivers\BSP;..\Drivers\User_Library\app;..\Drivers\User_Library\mid
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group Application/User
    ../Src/: main.c gpio.c usart.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Library/sys
    ../Drivers/User_Library/sys/: sys_timer.c sys_timer.h
  group Library/op
    ../Drivers/User_Library/op/: Op_HeaderDefine.h Op_HeaderFlag.h Op_HeaderMain.h Op_HeaderVariable.h Op_HeaderFunction.c Op_HeaderFunction.h
  group BSP
    ../Drivers/BSP/: stm32f769i_discovery.c
  group Library/app
    ../Drivers/User_Library/app/: App_Bootloader.h App_Bootloader.c
  group Library/mid
    ../Drivers/User_Library/mid/: Mid_PCubeProtocol.h Mid_PCubeProtocol.c Mid_FlashControl.c Mid_FlashControl.h
software components: CMSIS:CORE 4.3.0
